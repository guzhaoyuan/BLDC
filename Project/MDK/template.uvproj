# Keil uVision project template.uvproj, settings and files
target Template (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: template +hex
  c flags: Optim=1
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../src/: main.c nvic.c usart.c
    ../inc/: stm32f4xx_conf.h stm32f4xx_it.h
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CORE
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../../Libraries/CMSIS/Include/: core_cm4.h
  group LIB
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
